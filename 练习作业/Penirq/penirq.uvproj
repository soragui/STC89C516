# Keil uVision project penirq.uvproj, settings and files
target PEN (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: penirq +hex
  c flags: Optimize=8 SizeSpeed=1
  group source
    ./: initLCD.c main.c pen.c
  group include
    ./: initLCD.h pen.h
