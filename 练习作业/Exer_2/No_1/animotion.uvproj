# Keil uVision project animotion.uvproj, settings and files
target ANIMATION (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: animotion +hex
  c flags: Optimize=8 SizeSpeed=1
  group source
    ./: STARTUP.A51 initLCD.c main.c
  group include
    ./: initLCD.h ch_a.h
