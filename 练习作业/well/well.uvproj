# Keil uVision project well.uvproj, settings and files
target TARGET (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: well +hex
  c flags: Optimize=8 SizeSpeed=1
  group source
    ./: main.c NBCTFT.C
  group include
    ./: ch_a.h NBCTFT.H
