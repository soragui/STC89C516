# Keil uVision project my-welcom.uvproj, settings and files
target WEL (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: my-welcom +hex
  c flags: Optimize=8 SizeSpeed=1
  group source
    ./: STARTUP.A51 NBCTFT.C main.c
  group include
    ./: name.h NBCTFT.H
