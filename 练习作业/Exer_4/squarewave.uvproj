# Keil uVision project squarewave.uvproj, settings and files
target SQUARE (MCS-51)
  device: STC12C5A60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: squarewave +hex
  c flags: Optimize=8 SizeSpeed=1
  group source
    ./: initLCD.c start_task.c
  group include
    ./: initLCD.h
