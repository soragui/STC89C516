# Keil uVision project touch24libtest.uvproj, settings and files
target LIBTEST (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: touch24libtest +hex
  c flags: Optimize=8 SizeSpeed=1
  group main
    ./: main.c
