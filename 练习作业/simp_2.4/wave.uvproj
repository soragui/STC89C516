# Keil uVision project wave.uvproj, settings and files
target WAVE (MCS-51)
  device: STC89C58RD+ STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0x7FFF) CLOCK(45000000) MODP2
  output: wave +hex
  c flags: Optimize=8 SizeSpeed=1
  group source
    ./: initLCD.c startup.c
  group include
    ./: initLCD.h
