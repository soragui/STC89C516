# Keil uVision project timer-led.uvproj, settings and files
target TIMER_LED (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: timer-led +hex
  c flags: Optimize=8 SizeSpeed=1
  group source
    ./: STARTUP.A51 timer.c main.c
  group include
    ./: timer.h
