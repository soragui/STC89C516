# Keil uVision project simled.uvproj, settings and files
target SIMLED (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: simled +hex
  c flags: Optimize=8 SizeSpeed=1
  group src
    ./: simled.c
