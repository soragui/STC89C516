# Keil uVision project stc.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C58RD+ STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0x7FFF) CLOCK(45000000) MODP2
  output: stc +hex
  c flags: Optimize=8 SizeSpeed=1
  group source
    ./: stc_startup.c
