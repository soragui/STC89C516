# Keil uVision project ch_light.uvproj, settings and files
target CH_LIG (MCS-51)
  device: STC12C5A60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: ch_light +hex
  c flags: Optimize=8 SizeSpeed=1
  group source
    ./: initLCD.c main.c PCF.c
  group include
    ./: initLCD.h character.h PCF.h
