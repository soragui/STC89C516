# Keil uVision project voltage.uvproj, settings and files
target VOLTAGE (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: voltage +hex
  c flags: Optimize=8 SizeSpeed=1
  group source
    ./: STARTUP.A51 initLCD.c main.c PCF.c
  group include
    ./: initLCD.h num.h PCF.h
