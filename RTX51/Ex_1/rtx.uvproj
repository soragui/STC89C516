# Keil uVision project rtx.uvproj, settings and files
target RTX (MCS-51)
  device: STC12C5A60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: rtx +hex
  c flags: Optimize=8 SizeSpeed=1
  group source
    ./: rtx51.c
  group include
    ./: rtx51.h
