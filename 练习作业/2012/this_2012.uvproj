# Keil uVision project this_2012.uvproj, settings and files
target 2012 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: this_2012 +hex
  c flags: Optimize=8 SizeSpeed=1
  group source
    ./: STARTUP.A51 main.c NBCTFT.H NBCTFT.C ad_c.c
  group include
    ./: NBCTFT.H ad_c.h ch_a.h
